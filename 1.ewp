# IAR project 1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x00
  ICCSTM8.CCIncludePath2: D:\Study\MC\STM8_SNAKE
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s103f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: 1.out
  group (top)
    ./: main.c
  group Library
    ./: Buttons.c Buttons.h fontNumbers.h nokia.c nokia.h nokia_fastGFX.c nokia_fastGFX.h nokia_gfx.c nokia_gfx.h PingPong.c PingPong.h Snake.c Snake.h Snake_old.c Sprites.h Tetris.c Tetris.h tim4millis.c tim4millis.h
